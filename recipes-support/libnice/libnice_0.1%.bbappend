DEPENDS:append:qcom = " gstreamer1.0"
PACKAGECONFIG:append:qcom = " gstreamer"
