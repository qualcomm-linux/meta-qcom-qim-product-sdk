require gstreamer1.0-common.inc
