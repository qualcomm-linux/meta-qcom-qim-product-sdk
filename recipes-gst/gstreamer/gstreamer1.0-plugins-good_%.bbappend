require gstreamer1.0-common.inc

DEPENDS:append:qcom = " gtk+3"
PACKAGECONFIG:append:qcom = " gtk"
