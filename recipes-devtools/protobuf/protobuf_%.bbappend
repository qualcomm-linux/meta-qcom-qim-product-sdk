EXTRA_OECONF:append:qcom-custom-bsp = " --with-pic"
