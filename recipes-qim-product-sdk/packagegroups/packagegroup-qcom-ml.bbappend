RDEPENDS:${PN}:append:qcom-custom-bsp = "  \
      qcom-qnn-sdk \
      qcom-snpe-sdk \
    "
