RDEPENDS:packagegroup-qcom-gst:append:qcom-custom-bsp = "  \
        qcom-gstreamer1.0-plugins-oss-mlsnpe \
        qcom-gstreamer1.0-plugins-oss-mlqnn \
        qcom-gstreamer1.0-plugins-oss-mltflite \
  "

